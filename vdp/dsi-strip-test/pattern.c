/* Static HDMI timing test, separate from the maintained Extender renderer.
 * Geometry and drawing below are project-owned. The printable ASCII 6x8
 * glyph rows are copied unchanged from ../vendor/vdp-gl/src/fonts/font_6x8.h,
 * FONT_6x8_DATA (characters 32..126). This avoids a FabGL/SDK dependency in
 * the standalone test. Font: Copyright (c) 2019-2022 Fabrizio Di Vittorio;
 * GPL-3.0-or-later, as stated in ../vendor/vdp-gl/src/fabfonts.cpp. See
 * ../vendor/vdp-gl/LICENSE. Changes: printable subset and plain C wrapper.
 */
#include "pattern.h"

#include <limits.h>
#include <stdio.h>

static const uint8_t font_6x8[95][8] = {
    { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 }, /* 32 */
    { 0x20, 0x70, 0x70, 0x20, 0x20, 0x00, 0x20, 0x00 }, /* 33 */
    { 0x50, 0x50, 0x50, 0x00, 0x00, 0x00, 0x00, 0x00 }, /* 34 */
    { 0x50, 0x50, 0xf8, 0x50, 0xf8, 0x50, 0x50, 0x00 }, /* 35 */
    { 0x20, 0x78, 0x80, 0x70, 0x08, 0xf0, 0x60, 0x00 }, /* 36 */
    { 0x00, 0xc8, 0x90, 0x20, 0x40, 0x48, 0x98, 0x00 }, /* 37 */
    { 0x20, 0x50, 0x20, 0xa8, 0x90, 0x90, 0x68, 0x00 }, /* 38 */
    { 0x20, 0x20, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00 }, /* 39 */
    { 0x20, 0x40, 0x80, 0x80, 0x80, 0x40, 0x20, 0x00 }, /* 40 */
    { 0x40, 0x20, 0x10, 0x10, 0x10, 0x20, 0x40, 0x00 }, /* 41 */
    { 0x00, 0x50, 0x20, 0xf8, 0x20, 0x50, 0x00, 0x00 }, /* 42 */
    { 0x00, 0x10, 0x10, 0x7c, 0x10, 0x10, 0x00, 0x00 }, /* 43 */
    { 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x20, 0x40 }, /* 44 */
    { 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00 }, /* 45 */
    { 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x20, 0x00 }, /* 46 */
    { 0x00, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x00 }, /* 47 */
    { 0x70, 0x88, 0x98, 0xa8, 0xc8, 0xc8, 0x70, 0x00 }, /* 48 */
    { 0x20, 0x60, 0xa0, 0x20, 0x20, 0x20, 0xf8, 0x00 }, /* 49 */
    { 0x70, 0x88, 0x08, 0x30, 0x60, 0x88, 0xf8, 0x00 }, /* 50 */
    { 0x70, 0x88, 0x08, 0x30, 0x08, 0x88, 0x70, 0x00 }, /* 51 */
    { 0x10, 0x30, 0x50, 0x90, 0xf8, 0x10, 0x38, 0x00 }, /* 52 */
    { 0xf8, 0x80, 0x80, 0xf0, 0x08, 0x88, 0x70, 0x00 }, /* 53 */
    { 0x30, 0x40, 0x80, 0xf0, 0x88, 0x88, 0x70, 0x00 }, /* 54 */
    { 0xf8, 0x88, 0x10, 0x20, 0x40, 0x40, 0x40, 0x00 }, /* 55 */
    { 0x70, 0x88, 0x88, 0x70, 0x88, 0x88, 0x70, 0x00 }, /* 56 */
    { 0x70, 0x88, 0x88, 0x78, 0x08, 0x08, 0x70, 0x00 }, /* 57 */
    { 0x00, 0x20, 0x20, 0x00, 0x00, 0x20, 0x20, 0x00 }, /* 58 */
    { 0x00, 0x20, 0x20, 0x00, 0x00, 0x20, 0x20, 0x40 }, /* 59 */
    { 0x10, 0x20, 0x40, 0x80, 0x40, 0x20, 0x10, 0x00 }, /* 60 */
    { 0x00, 0x00, 0xf8, 0x00, 0x00, 0xf8, 0x00, 0x00 }, /* 61 */
    { 0x40, 0x20, 0x10, 0x08, 0x10, 0x20, 0x40, 0x00 }, /* 62 */
    { 0x70, 0x88, 0x08, 0x10, 0x20, 0x00, 0x20, 0x00 }, /* 63 */
    { 0x70, 0x88, 0xb8, 0xa8, 0xb8, 0x80, 0x70, 0x00 }, /* 64 */
    { 0x20, 0x50, 0x88, 0x88, 0xf8, 0x88, 0x88, 0x00 }, /* 65 */
    { 0xf0, 0x48, 0x48, 0x70, 0x48, 0x48, 0xf0, 0x00 }, /* 66 */
    { 0x30, 0x48, 0x80, 0x80, 0x80, 0x48, 0x30, 0x00 }, /* 67 */
    { 0xf0, 0x48, 0x48, 0x48, 0x48, 0x48, 0xf0, 0x00 }, /* 68 */
    { 0xf8, 0x48, 0x40, 0x70, 0x40, 0x48, 0xf8, 0x00 }, /* 69 */
    { 0xf8, 0x48, 0x40, 0x70, 0x40, 0x40, 0xe0, 0x00 }, /* 70 */
    { 0x30, 0x48, 0x80, 0x80, 0x98, 0x48, 0x38, 0x00 }, /* 71 */
    { 0x88, 0x88, 0x88, 0xf8, 0x88, 0x88, 0x88, 0x00 }, /* 72 */
    { 0x70, 0x20, 0x20, 0x20, 0x20, 0x20, 0x70, 0x00 }, /* 73 */
    { 0x38, 0x10, 0x10, 0x10, 0x90, 0x90, 0x60, 0x00 }, /* 74 */
    { 0xc8, 0x50, 0x50, 0x60, 0x50, 0x50, 0xcc, 0x00 }, /* 75 */
    { 0xe0, 0x40, 0x40, 0x40, 0x40, 0x48, 0xf8, 0x00 }, /* 76 */
    { 0x88, 0xd8, 0xa8, 0xa8, 0x88, 0x88, 0x88, 0x00 }, /* 77 */
    { 0x88, 0xc8, 0xa8, 0x98, 0x88, 0x88, 0x88, 0x00 }, /* 78 */
    { 0x70, 0x88, 0x88, 0x88, 0x88, 0x88, 0x70, 0x00 }, /* 79 */
    { 0xf0, 0x48, 0x48, 0x70, 0x40, 0x40, 0xe0, 0x00 }, /* 80 */
    { 0x70, 0x88, 0x88, 0x88, 0x88, 0xa8, 0x70, 0x0c }, /* 81 */
    { 0xf0, 0x48, 0x48, 0x70, 0x60, 0x50, 0xc8, 0x00 }, /* 82 */
    { 0x70, 0x88, 0x80, 0x70, 0x08, 0x88, 0x70, 0x00 }, /* 83 */
    { 0xf8, 0xa8, 0x20, 0x20, 0x20, 0x20, 0x70, 0x00 }, /* 84 */
    { 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x70, 0x00 }, /* 85 */
    { 0x88, 0x88, 0x88, 0x88, 0x88, 0x50, 0x20, 0x00 }, /* 86 */
    { 0x88, 0x88, 0x88, 0xa8, 0xa8, 0xa8, 0x50, 0x00 }, /* 87 */
    { 0x88, 0x50, 0x50, 0x20, 0x50, 0x50, 0x88, 0x00 }, /* 88 */
    { 0x88, 0x88, 0x50, 0x20, 0x20, 0x20, 0x70, 0x00 }, /* 89 */
    { 0xf8, 0x88, 0x10, 0x20, 0x40, 0x88, 0xf8, 0x00 }, /* 90 */
    { 0xe0, 0x80, 0x80, 0x80, 0x80, 0x80, 0xe0, 0x00 }, /* 91 */
    { 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00 }, /* 92 */
    { 0xe0, 0x20, 0x20, 0x20, 0x20, 0x20, 0xe0, 0x00 }, /* 93 */
    { 0x20, 0x50, 0x88, 0x88, 0x00, 0x00, 0x00, 0x00 }, /* 94 */
    { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xfc }, /* 95 */
    { 0x20, 0x20, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00 }, /* 96 */
    { 0x00, 0x00, 0x70, 0x08, 0x78, 0x88, 0x7c, 0x00 }, /* 97 */
    { 0xc0, 0x40, 0x40, 0x50, 0x68, 0x48, 0xb0, 0x00 }, /* 98 */
    { 0x00, 0x00, 0x70, 0x88, 0x80, 0x88, 0x70, 0x00 }, /* 99 */
    { 0x18, 0x08, 0x08, 0x68, 0x98, 0x98, 0x6c, 0x00 }, /* 100 */
    { 0x00, 0x00, 0x70, 0x88, 0xf8, 0x80, 0x70, 0x00 }, /* 101 */
    { 0x30, 0x48, 0x40, 0xe0, 0x40, 0x40, 0xe0, 0x00 }, /* 102 */
    { 0x00, 0x00, 0x68, 0x88, 0x88, 0x78, 0x08, 0xf0 }, /* 103 */
    { 0xc0, 0x40, 0x50, 0x68, 0x48, 0x48, 0xc8, 0x00 }, /* 104 */
    { 0x20, 0x00, 0x60, 0x20, 0x20, 0x20, 0x70, 0x00 }, /* 105 */
    { 0x08, 0x00, 0x18, 0x08, 0x08, 0x88, 0x88, 0x70 }, /* 106 */
    { 0xc0, 0x40, 0x48, 0x50, 0x60, 0x50, 0x48, 0x00 }, /* 107 */
    { 0x60, 0x20, 0x20, 0x20, 0x20, 0x20, 0x70, 0x00 }, /* 108 */
    { 0x00, 0x00, 0xd0, 0xa8, 0xa8, 0xa8, 0xa8, 0x00 }, /* 109 */
    { 0x00, 0x00, 0xb0, 0xc8, 0x88, 0x88, 0x88, 0x00 }, /* 110 */
    { 0x00, 0x00, 0x70, 0x88, 0x88, 0x88, 0x70, 0x00 }, /* 111 */
    { 0x00, 0x00, 0xf0, 0x48, 0x48, 0x70, 0x40, 0xe0 }, /* 112 */
    { 0x00, 0x00, 0x68, 0x90, 0x90, 0x70, 0x10, 0x38 }, /* 113 */
    { 0x00, 0x00, 0xd8, 0x68, 0x40, 0x40, 0xe0, 0x00 }, /* 114 */
    { 0x00, 0x00, 0x78, 0x80, 0x70, 0x08, 0xf0, 0x00 }, /* 115 */
    { 0x40, 0x40, 0xf0, 0x40, 0x40, 0x48, 0x30, 0x00 }, /* 116 */
    { 0x00, 0x00, 0x88, 0x88, 0x88, 0x98, 0x68, 0x00 }, /* 117 */
    { 0x00, 0x00, 0x88, 0x88, 0x88, 0x50, 0x20, 0x00 }, /* 118 */
    { 0x00, 0x00, 0x88, 0xa8, 0xa8, 0xa8, 0x50, 0x00 }, /* 119 */
    { 0x00, 0x00, 0x88, 0x50, 0x20, 0x50, 0x88, 0x00 }, /* 120 */
    { 0x00, 0x00, 0x88, 0x88, 0x88, 0x78, 0x08, 0xf0 }, /* 121 */
    { 0x00, 0x00, 0xf8, 0x10, 0x20, 0x40, 0xf8, 0x00 }, /* 122 */
    { 0x18, 0x20, 0x20, 0xc0, 0x20, 0x20, 0x18, 0x00 }, /* 123 */
    { 0x20, 0x20, 0x20, 0x00, 0x20, 0x20, 0x20, 0x00 }, /* 124 */
    { 0xc0, 0x20, 0x20, 0x18, 0x20, 0x20, 0xc0, 0x00 }, /* 125 */
    { 0x48, 0xb0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 }, /* 126 */
};

typedef struct {
    uint8_t *pixels;
    size_t stride;
    int width, height;
} surface_t;

static void pixel(surface_t *s, int x, int y, uint32_t rgb)
{
    if (x < 0 || y < 0 || x >= s->width || y >= s->height)
        return;
    uint8_t *p = s->pixels + (size_t)y * s->stride + (size_t)x * 3;
    p[0] = (uint8_t)rgb;
    p[1] = (uint8_t)(rgb >> 8);
    p[2] = (uint8_t)(rgb >> 16);
}

static void rectangle(surface_t *s, int x, int y, int w, int h, uint32_t rgb)
{
    for (int yy = 0; yy < h; ++yy)
        for (int xx = 0; xx < w; ++xx)
            pixel(s, x + xx, y + yy, rgb);
}

static void outline(surface_t *s, int x, int y, int w, int h, uint32_t rgb)
{
    rectangle(s, x, y, w, 1, rgb);
    rectangle(s, x, y + h - 1, w, 1, rgb);
    rectangle(s, x, y, 1, h, rgb);
    rectangle(s, x + w - 1, y, 1, h, rgb);
}

static void text(surface_t *s, int x, int y, const char *str, int scale,
                 uint32_t rgb)
{
    for (; *str; ++str, x += 6 * scale) {
        unsigned ch = (unsigned char)*str;
        if (ch < 32 || ch > 126)
            ch = '?';
        for (int row = 0; row < 8; ++row)
            for (int col = 0; col < 6; ++col)
                if (font_6x8[ch - 32][row] & (0x80u >> col))
                    rectangle(s, x + col * scale, y + row * scale,
                              scale, scale, rgb);
    }
}

bool hdmi_timing_pattern_bgr888(uint8_t *pixels, size_t size_bytes,
                              size_t stride_bytes, unsigned width,
                              unsigned height)
{
    /* Check every multiplication before touching caller storage. INT_MAX/2
     * also leaves room for the small signed drawing offsets below. */
    if (!pixels || width < 640 || height < 480 ||
        width > INT_MAX / 2 || height > INT_MAX / 2 ||
        SIZE_MAX / width < 3)
        return false;
    size_t row_bytes = (size_t)width * 3;
    if (stride_bytes < row_bytes ||
        (size_t)(height - 1) > (SIZE_MAX - row_bytes) / stride_bytes ||
        size_bytes < (size_t)(height - 1) * stride_bytes + row_bytes)
        return false;

    surface_t s = { pixels, stride_bytes, (int)width, (int)height };
    const int left = ((int)width - 512) / 2;
    const int top = ((int)height - 384) / 2;
    const uint32_t white = 0xffffff;
    const uint32_t bars[8] = {
        0x000000, 0xff0000, 0x00ff00, 0x0000ff,
        0xffff00, 0xff00ff, 0x00ffff, 0xffffff
    };
    const char *const names[8] = { "K", "R", "G", "B", "Y", "M", "C", "W" };

    rectangle(&s, 0, 0, s.width, s.height, 0);
    char mode[40];
    snprintf(mode, sizeof mode, "%ux%u HDMI timing test", width, height);
    text(&s, (s.width - 27 * 12) / 2, 10, mode, 2, white);
    text(&s, left + 40, top + 10, "512x384 unscaled - check aspect", 2, white);
    text(&s, left + 28, top + 30, "Black  Red  Green  Blue  Yellow  Magenta  Cyan  White", 1, white);

    for (int bar = 0; bar < 8; ++bar) {
        rectangle(&s, left + bar * 64, top + 48, 64, 128, bars[bar]);
        text(&s, left + bar * 64 + 26, top + 57, names[bar], 2,
             bar == 0 || bar == 1 || bar == 3 || bar == 5 ? white : 0);
    }

    text(&s, left + 16, top + 186, "1-pixel checker", 1, white);
    text(&s, left + 192, top + 186, "8-pixel checker", 1, white);
    text(&s, left + 392, top + 186, "Circle", 1, white);
    for (int y = 0; y < 64; ++y)
        for (int x = 0; x < 128; ++x) {
            pixel(&s, left + 16 + x, top + 204 + y,
                  ((x + y) & 1) ? 0 : white);
            pixel(&s, left + 192 + x, top + 204 + y,
                  (((x / 8) + (y / 8)) & 1) ? 0 : white);
        }
    /* The circle and square expose unexpected aspect stretching. */
    for (int y = -36; y <= 36; ++y)
        for (int x = -36; x <= 36; ++x) {
            int radius2 = x * x + y * y;
            if (radius2 >= 34 * 34 && radius2 <= 36 * 36)
                pixel(&s, left + 416 + x, top + 236 + y, white);
        }
    text(&s, left + 16, top + 286, "1-pixel lines", 1, white);
    text(&s, left + 424, top + 286, "64x64", 1, white);
    for (int y = 0; y < 48; ++y)
        for (int x = 0; x < 160; ++x) {
            pixel(&s, left + 16 + x, top + 312 + y, (y & 1) ? 0 : white);
            pixel(&s, left + 208 + x, top + 312 + y, (x & 1) ? 0 : white);
        }
    outline(&s, left + 424, top + 308, 64, 64, white);
    outline(&s, left, top, 512, 384, white);

    text(&s, (s.width - 38 * 12) / 2, s.height - 32,
         "Visual validation - screenshot requested", 2, white);
    /* The white outside frame must be continuous, including all four corners.
     * Distinct identifiers sit inside it, never replacing its corner pixels. */
    rectangle(&s, 4, 4, 8, 24, 0xff0000);
    text(&s, 16, 8, "1 TL", 2, white);
    rectangle(&s, s.width - 12, 4, 8, 24, 0x00ff00);
    text(&s, s.width - 68, 8, "2 TR", 2, white);
    rectangle(&s, 4, s.height - 28, 8, 24, 0x0000ff);
    text(&s, 16, s.height - 24, "3 BL", 2, white);
    rectangle(&s, s.width - 12, s.height - 28, 8, 24, 0xffff00);
    text(&s, s.width - 68, s.height - 24, "4 BR", 2, white);
    outline(&s, 0, 0, s.width, s.height, white);
    /* Contrasting inner edge ticks reveal a one-line wrap/shift. */
    rectangle(&s, s.width / 2 - 32, 1, 64, 1, 0xff0000);
    rectangle(&s, s.width / 2 - 32, s.height - 2, 64, 1, 0x00ffff);
    return true;
}
